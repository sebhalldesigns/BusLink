File: mcu.kicad_sch (KiCad schematic)
At the start: 1 part, among them U1 STM32H723VETx

Commit message: working on power supplies and CAN
Other:
- moved on the sheet: U1
